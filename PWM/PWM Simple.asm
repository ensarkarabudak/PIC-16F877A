#INCLUDE <P16F877A.INC>
GOTO ANAPROGRAM
ORG 0X04
RETFIE

ANAPROGRAM
		BANKSEL TRISC
		CLRF TRISC
		BANKSEL PR2
		movlw d'99'
		movwf PR2
		BANKSEL CCPR1L
		MOVLW D'80'
		MOVWF CCPR1L
		BANKSEL CCP1CON
		MOVLW D'12'
		MOVWF CCP1CON
		BANKSEL INTCON
		BSF INTCON,PEIE
		BSF INTCON,GIE
		BANKSEL T2CON
		MOVLW B'00000100'
		MOVWF T2CON
DONGU 
GOTO DONGU
		

		

END