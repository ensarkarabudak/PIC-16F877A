    	
    	;*********************** TÝMER0 LA LED ÜZERÝNDE SAYICI*********************
    	
    	
    	LIST    p=16F877
		#include "P16F877.INC"
		
		SAYAC EQU 20H  	  ; Dönglerde kullanýlacak sayaclarý tanýmla
		DEGER EQU 23H     ; Her seferinde portb'ye gödereceðin binary deðer
		ORG 0
 		GOTO ANA_PROGRAM
		ORG 4
		GOTO KESME

	ILK_ISLEM:
		MOVLW h'20'
		MOVWF SAYAC
		BSF STATUS,5	  ; BANK1 'e geç
 		BCF STATUS,6
		MOVLW B'00000111' ; Option register'ýn prescaler ve tocs(clock seçme) ayarý.. 
		MOVWF OPTION_REG
		BSF INTCON,5
		BSF INTCON,GIE    ;Tüm kesme iþlemlerine izin vedik
		MOVLW h'00'
		MOVWF TRISB		  ; Portb'yi çýkýþ yap
		BCF STATUS,5 	  ; Bank0'a geç
		MOVWF PORTB
		MOVWF DEGER
		MOVWF TMR0
		RETURN 


	KESME:
		BCF INTCON,2	  ;Timer0'ýn taþma flaðýný sýfýrlýyoruz
		DECFSZ SAYAC,1		
		RETFIE		
		MOVLW H'00'		
		MOVWF TMR0		  ;Timero yeniden kuruyoruz
		INCF DEGER,1	  ;Degeri 1 arttýr
		MOVFW DEGER
		MOVWF PORTB		  ;PORTB yi 1 arttýr;
		MOVLW H'20'		  ;Sayacý yeniden kuruyoruz
		MOVWF SAYAC
		RETFIE


	ANA_PROGRAM:
		CALL ILK_ISLEM
	SONSUZ:
		GOTO SONSUZ

		END
