LIST P=16F877A
#INCLUDE <P16F877A.INC>

SAYAC EQU 0X22
SAYI EQU 0X23
ORG 0X00
GOTO MAIN

ORG 0X04
GOTO KESME


KESME
BCF PIR1,TMR2IF
BANKSEL SAYAC
DECFSZ SAYAC,F
RETFIE
MOVLW D'250'
MOVWF SAYAC
COMF PORTB,F
RETFIE


MAIN

BANKSEL TRISB
CLRF TRISB
BANKSEL PORTB
BSF PORTB,0

MOVLW B'11000000'
MOVWF INTCON

BANKSEL PIE1
BSF PIE1,TMR2IE

BANKSEL T2CON
MOVLW B'01111101' ; POST 1/16  PRE:1/4
MOVWF T2CON


BANKSEL PR2
MOVLW D'62'
MOVWF PR2

BANKSEL SAYAC
MOVLW D'250'
MOVWF SAYAC

DONGU
GOTO DONGU

END