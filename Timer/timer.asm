;TÝMER 0 LED YAKIP SONDÜRME 0,5 SN
	 list p=16F877A
	#include <P16F877A.INC>
	SAYAC EQU 0X21
	ORG 0X00
	GOTO ANA
	ORG 0X4
KESME
	BCF INTCON,T0IF
	DECFSZ SAYAC,F
	GOTO KESMEDENDON
LED
	MOVLW .18
	MOVWF SAYAC
	MOVLW 08H
	XORWF PORTB
	
KESMEDENDON
	BANKSEL 81H
	MOVLW 07H
	MOVWF OPTION_REG
	BANKSEL SAYAC
	MOVLW .39
	MOVWF TMR0
	RETFIE
	

ANA
	BSF INTCON,GIE
	BSF INTCON,PEIE
	BSF INTCON,T0IE
	BCF INTCON,T0IF
	BANKSEL 81H
	CLRF TRISB
	MOVLW 07H
	MOVWF OPTION_REG
	BANKSEL SAYAC
	MOVLW .18
	MOVWF SAYAC
	MOVLW .39
	MOVWF TMR0
	CLRF PORTB
DONGU
	GOTO DONGU
END
