
		ORG		0X00
		GOTO	HAZIRLA
		ORG		0X04
		GOTO	KESME
HAZIRLA
		CLRF	PORTD
		BSF		STATUS,RP0
		CLRF	TRISD
		
		BSF		PIE1,0

		BCF		STATUS,RP0
		
		BSF		INTCON,GIE
		BSF		INTCON,PEIE
		BCF		T1CON,1
		BSF		T1CON,0
		BSF		T1CON,4
		BSF		T1CON,5
		
		BCF		STATUS,RP0
LOOP
		NOP
		NOP
		GOTO	LOOP

KESME
		BCF		PIR1,0
		MOVLW	H'0B'
		MOVWF	TMR1H
		MOVLW	H'DC'
		MOVWF	TMR1L
		
		INCF	PORTD,F
RETFIE

END
		