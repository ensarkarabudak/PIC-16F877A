	list p=16F877	
	include"p16F877.inc"
	SAYAC0 EQU 0X20
	SAYAC1 EQU 0X21
	
	ORG 0X00
	GOTO ANA_PROGRAM
	ORG 0X04
	GOTO KESME
	
ANA_PROGRAM
	BANKSEL TRISD
	CLRF TRISD
	BANKSEL PORTD
	CLRF PORTD
	BANKSEL T1CON
	MOVLW h'01'
	MOVWF T1CON
	BANKSEL PIE1
	BSF PIE1,TMR1IE
	BANKSEL INTCON
	MOVLW h'C0'
	MOVWF INTCON
	MOVLW h'FF'
	MOVWF SAYAC0

SONSUZ
	GOTO SONSUZ

KESME
	BTFSS PIR1,TMR1IF
	RETFIE
	BCF PIR1,TMR1IF
	CALL GECÝK
	INCF PORTD
	RETFIE

GECÝK
	MOVLW h'FF'
	MOVWF SAYAC1
	DECFSZ SAYAC0,1
	RETURN
DÖN
	DECFSZ SAYAC1,1
	GOTO DÖN 	
	GOTO GECÝK
	
END
	