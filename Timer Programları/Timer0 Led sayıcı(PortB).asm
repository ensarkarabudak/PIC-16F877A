;***********************************************************************************
;**********************Timer0 ile PortB üzerinde led sayýcý...**********************



list P = 16F877
include p16f877.inc

Sayac equ h'20'
Led equ h'21'

org 0x0000 
goto Basla
org 0x0004
	bcf INTCON,T0IF			;flaðý sýfýrla
	incf Sayac,f				;sayacý arttýr (260ms @ 8Mhz)
	retfie
	
Basla:
	bsf STATUS,RP0			;bank1
	movlw 0x02
	movwf OPTION_REG			;1:4 prescaler
	clrf TRISB				;C portu çýkýþ
	bcf STATUS,RP0 			;bank0
	clrf Sayac
	clrf Led
	clrf PORTB
	clrf TMR0				;timeri sýfýrla
	movlw b'11100000'
	movwf INTCON				;interruptlar açýk
	;goto LedSay

LedSay:
	incf Led
	movf Led,w
	movwf PORTB
	;goto Bekle

Bekle:
	btfss STATUS,Z
	goto Bekle
	goto LedSay
end
