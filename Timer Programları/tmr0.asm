#INCLUDE <P16F877.INC>

	INTX	EQU		0X33
	ORG		0X00
	GOTO	PROGRAM
	ORG		0X04
	GOTO 	KESME

PROGRAM

	MOVLW	D'250'
	MOVWF	INTX

	BANKSEL	TRISB
	CLRF	TRISB
	BANKSEL	PORTB
	MOVLW	0X01
	MOVWF	PORTB

	MOVLW	B'11010001'
	BANKSEL	OPTION_REG
	MOVWF	OPTION_REG

	BANKSEL	TMR0
	MOVLW	D'6'
	MOVWF	TMR0
	
	BSF		INTCON,D'5'
	BSF		INTCON,D'7'

	GOTO	DONGU
KESME
	BTFSS	INTCON,5
	RETFIE
	BTFSS	INTCON,2
	RETFIE
	DECFSZ	INTX,1
	GOTO	DENE
	GOTO	YAK
DENE
	MOVLW	D'6'
	MOVWF	TMR0
	BCF		INTCON,2
	RETFIE
YAK
	RLF		PORTB,1
	MOVLW	D'6'
	MOVWF	TMR0
	MOVLW	D'250'
	MOVWF	INTX
	RETFIE
DONGU
	GOTO	DONGU
END