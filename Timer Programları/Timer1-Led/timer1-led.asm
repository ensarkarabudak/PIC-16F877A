LIST P=16F877A
#INCLUDE <P16F877A.INC>
SAYAC EQU 0X20
ORG 0X00
GOTO MAIN

ORG 0X04
GOTO KESME

KESME
BCF PIR1,TMR1IF
BANKSEL TMR1H
MOVLW H'3C'
MOVWF TMR1H
MOVLW H'B0'
MOVWF TMR1L

DECFSZ SAYAC,F
RETFIE
MOVLW D'5'
MOVWF SAYAC
COMF PORTB,F
RETFIE

MAIN
BANKSEL TRISB
CLRF TRISB
BANKSEL PORTB
BSF PORTB,0

BANKSEL TMR1H
MOVLW H'3C'
MOVWF TMR1H
MOVLW H'B0'
MOVWF TMR1L

BANKSEL INTCON
MOVLW B'11000000'
MOVWF INTCON

BANKSEL PIE1
BSF PIE1,TMR1IE

BANKSEL T1CON
MOVLW B'00100001' ; 1/4 TMR1 0N
MOVWF T1CON

BANKSEL SAYAC
MOVLW D'5'
MOVWF SAYAC

DONGU
GOTO DONGU

END