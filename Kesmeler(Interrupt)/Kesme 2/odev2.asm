INCLUDE <P16F628A.INC>
	ORG 	0X00
	GOTO	ANA
	ORG		0X04
	GOTO	KESME

ANA
	CLRF	PORTB
	BANKSEL	TRISB
	CLRF	TRISB
	MOVLW	B'11010111'
	MOVWF	OPTION_REG
	BANKSEL	PORTB
	BSF		INTCON,7
	BSF		INTCON,5
	MOVLW	D'60'
	MOVWF	TMR0
DONGU
	GOTO	DONGU

KESME
	BCF		INTCON,2
	MOVLW	D'60'
	MOVWF	TMR0
	COMF	PORTB,1
	RETFIE
	
END