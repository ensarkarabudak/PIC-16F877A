#INCLUDE<P16F877.INC>

	ORG		0X00
	DEG1	EQU		0X33
	GOTO	START
START
	BANKSEL	TRISB
	BSF		TRISB,0
	BSF		TRISB,1
	CLRF	TRISD
	BANKSEL	PORTB
	MOVLW	0X01
	MOVWF	DEG1
DONGU
	BTFSS	PORTB,0
	GOTO	$+2
	GOTO	SAG_SAY
	BTFSS	PORTB,1
	GOTO	DUR
	GOTO	SOL_SAY
SAG_SAY
	RRF		DEG1,1
	MOVF	DEG1,0
	MOVWF	PORTD
	GOTO	DONGU
SOL_SAY
	RLF		DEG1,1
	MOVF	DEG1,0
	MOVWF	PORTD
	GOTO 	DONGU
DUR
	MOVF	DEG1,0
	MOVWF	PORTD
	GOTO	DONGU
END
